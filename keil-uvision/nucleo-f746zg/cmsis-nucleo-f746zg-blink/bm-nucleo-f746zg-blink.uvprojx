# Keil uVision project bm-nucleo-f746zg-blink.uvprojx, settings and files
target stm32f746zg (6140000::V6.14::ARMCLANG)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: bm-nucleo-f746zg-ra8835
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group main
    ./: main.c
  group customs
    ./: customs.c customs.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.5
